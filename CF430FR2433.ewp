# IAR project CF430FR2433.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430FR2433 MSP430FR2433
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: C:\Users\mka\Documents\GitHub\CF430FR2433-Launchpad\lnk430fr2433.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: CF430FR2433.s43 CF430FRforth.h infoB.s43 init430FR2433.s43 vecs430FR2433.s43
